options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: Keyboard-controlled GMSK command transmitter using a UHD USRP Sink
    generate_options: qt_gui
    id: gmsk_keyboard_tx_uhd
    output_language: python
    title: GMSK Keyboard Command TX - UHD
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2440000000'
  states: {}
- name: clock_source
  id: variable
  parameters:
    value: '"internal"'
  states: {}
- name: device_addr
  id: variable
  parameters:
    value: '""'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: time_source
  id: variable
  parameters:
    value: '"internal"'
  states: {}
- name: keyboard_source
  id: gpsk_comms_keyboard_command_source
  parameters:
    gui_hint: 0,0,1,1
  states: {}
- name: tx
  id: gpsk_comms_gmsk_command_tx
  parameters:
    access_code: D391DA26
    bt: '0.35'
    cycle_period: '0.5'
    demo_cycle: 'False'
    hold_to_send: 'True'
    repeat_rate: '100'
    sample_rate: samp_rate
    samples_per_symbol: '4'
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: antenna
    bw0: bandwidth
    center_freq0: center_freq
    clock_source0: clock_source
    dev_addr: device_addr
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    time_source0: time_source
    type: fc32
  states: {}

connections:
- [keyboard_source, command, tx, command]
- [tx, '0', usrp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
