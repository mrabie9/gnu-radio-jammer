options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: Capture stage of the replay attack. Records complex baseband IQ from a USRP to a file (cf32 / gr_complex) so replay_attack.grc can transmit it back. Centre frequency, sample rate and the target band (2392-2492 MHz or 5190-5290 MHz) are live sliders. Press Record to start writing to the file and release it to stop; the file is truncated each time the flowgraph starts. Capture at the same sample rate you intend to replay at, then run replay_attack.grc pointing at the same file.
    generate_options: qt_gui
    id: replay_capture
    output_language: python
    title: Replay Capture - record IQ to file
  states: {}

blocks:
- name: band
  id: variable_qtgui_chooser
  parameters:
    comment: 'Target allocation. Each option is a (low_hz, high_hz) tuple; the centre-frequency slider spans whichever band is selected here. Switching band while running snaps the radio to that band''s centre frequency. NOTE: the slider''s min/max endpoints are fixed when the flowgraph starts, so to slide freely across the other band, restart after changing this.'
    gui_hint: 0,0,1,2
    label: Target band
    num_opts: '2'
    type: raw
    value: (2392e6, 2492e6)
    option0: (2392e6, 2492e6)
    label0: 2.4 GHz (2392-2492 MHz)
    option1: (5190e6, 5290e6)
    label1: 5.2 GHz (5190-5290 MHz)
    options: '[]'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: USRP receive centre frequency, in Hz. The slider spans the band chosen above. Live within the band.
    gui_hint: 1,0,1,2
    label: Centre frequency (Hz)
    start: band[0]
    step: '1000000'
    stop: band[1]
    value: (band[0] + band[1]) / 2
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    comment: USRP sample rate, in Hz. Record at the same rate you plan to replay at. Live.
    gui_hint: 2,0,1,1
    label: Sample rate (Hz)
    start: '1000000'
    step: '1000000'
    stop: '56000000'
    value: '20000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: USRP receive gain in dB. Live.
    gui_hint: 2,1,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: record
  id: variable_qtgui_check_box
  parameters:
    comment: Ticked (default) writes samples to the file; untick to stop/pause. Recording starts as soon as the flowgraph runs, and the file is truncated at that point, so tune before you press Run if you want a clean capture.
    'false': 'False'
    gui_hint: 3,0,1,2
    label: Record to file (on by default)
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os, tempfile
  states: {}
- name: capture_file
  id: variable
  parameters:
    comment: Path the recording is written to (in the system temp dir, cross-platform). Point replay_attack.grc at this same file to transmit it back.
    value: os.path.join(tempfile.gettempdir(), "capture.cf32")
  states: {}
- name: device_addr
  id: variable
  parameters:
    comment: Empty takes the first device found; set a serial to pick one.
    value: '""'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: device_addr
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: record_valve
  id: blocks_copy
  parameters:
    comment: Passes samples through only while Record is ticked, gating what reaches the file.
    enabled: record
    type: complex
  states: {}
- name: file_sink
  id: blocks_file_sink
  parameters:
    comment: The captured recording. Truncated at start; written to while Record is ticked.
    file: capture_file
    type: complex
    unbuffered: 'True'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: Live receive spectrum, so you can see the signal before recording it.
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,0,1,1
    label1: rx
    name: '"Receive spectrum"'
    type: complex
    ymin: '-110'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Receive signal over time.
    fc: center_freq
    fftsize: '1024'
    gui_hint: 4,1,1,1
    int_min: '-110'
    name: '"Receive over time"'
    type: complex
  states: {}

connections:
- [usrp_source, '0', record_valve, '0']
- [usrp_source, '0', spectrum, '0']
- [usrp_source, '0', waterfall, '0']
- [record_valve, '0', file_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
