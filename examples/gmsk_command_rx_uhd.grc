options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: GMSK command receiver using a standard UHD USRP Source
    generate_options: no_gui
    id: gmsk_command_rx_uhd
    output_language: python
    title: GMSK Command RX - UHD
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2440000000'
  states: {}
- name: device_addr
  id: variable
  parameters:
    value: '"serial=3449B99"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: clock_source
  id: variable
  parameters:
    value: '"internal"'
  states: {}
- name: time_source
  id: variable
  parameters:
    value: '"internal"'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    bw0: bandwidth
    center_freq0: center_freq
    clock_source0: clock_source
    dev_addr: device_addr
    gain0: gain
    samp_rate: samp_rate
    time_source0: time_source
    type: fc32
  states: {}
- name: rx
  id: gpsk_comms_gmsk_command_rx
  parameters:
    access_code: D391DA26
    access_code_threshold: '2'
    bt: '0.35'
    sample_rate: samp_rate
    samples_per_symbol: '4'
    watchdog_timeout: '0.5'
  states: {}
- name: command_debug
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [usrp_source, '0', rx, '0']
- [rx, command, command_debug, print]

metadata:
  file_format: 1
