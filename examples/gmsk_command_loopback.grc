options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: GMSK command modem loopback without USRP hardware
    generate_options: no_gui
    id: gmsk_command_loopback
    output_language: python
    title: GMSK Command Loopback
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx
  id: gpsk_comms_gmsk_command_tx
  parameters:
    access_code: D391DA26
    access_code_threshold: '2'
    bt: '0.35'
    cycle_period: '0.5'
    demo_cycle: 'False'
    hold_to_send: 'False'
    repeat_rate: '10'
    sample_rate: samp_rate
    samples_per_symbol: '4'
  states: {}
- name: rx
  id: gpsk_comms_gmsk_command_rx
  parameters:
    access_code: D391DA26
    bt: '0.35'
    sample_rate: samp_rate
    samples_per_symbol: '4'
    watchdog_timeout: '0.5'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: command_strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.dict_add(pmt.make_dict(), pmt.intern("command"), pmt.intern("forward"))
    period: '1000'
  states: {}
- name: command_debug
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [command_strobe, strobe, tx, command]
- [rx, command, command_debug, print]
- [tx, '0', throttle, '0']
- [throttle, '0', rx, '0']

metadata:
  file_format: 1
