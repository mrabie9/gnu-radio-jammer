options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: 'Standalone sweep (chirp) jammer for two 100 MHz bands: 2392-2492 MHz and 5190-5290 MHz. A linear chirp sweeps across the instantaneous sample_rate window while the embedded block steps the USRP LO across each band and alternates between the two, covering the full 2 x 100 MHz. Speed and sample rate are live sliders. WARNING: this transmits -- only radiate in bands you are licensed for, into a load or attenuator. Both default bands overlap licensed services.'
    generate_options: qt_gui
    id: sweep_jammer
    output_language: python
    title: Sweep Jammer - two 100 MHz bands
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    comment: Instantaneous swept bandwidth, and the USRP sample rate. Live, though a real radio may glitch as it retunes its clocks -- for a jammer that does not matter. Keep it inside what your device and USB/Ethernet link can sustain.
    gui_hint: 1,0,1,1
    label: Sample rate (Hz)
    orient: Qt.Horizontal
    start: '1000000'
    step: '1000000'
    stop: '56000000'
    value: '10000000'
  states: {}
- name: speed
  id: variable_qtgui_range
  parameters:
    comment: Chirp sweeps per second across the sample_rate window. Higher dwells less on each frequency; lower puts more energy per visit. Live.
    gui_hint: 1,1,1,1
    label: Sweep speed (sweeps/s)
    orient: Qt.Horizontal
    start: '100'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: dwell
  id: variable_qtgui_range
  parameters:
    comment: Seconds the LO holds on each step before moving on. The full band revisit time is dwell times the number of LO steps. Live.
    gui_hint: 2,0,1,1
    label: LO dwell (s)
    orient: Qt.Horizontal
    start: '0.005'
    step: '0.005'
    stop: '0.2'
    value: '0.02'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: USRP transmit gain in dB. Live. Start low.
    gui_hint: 2,1,1,1
    label: TX gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: bands
  id: variable_qtgui_chooser
  parameters:
    comment: Which allocation(s) to sweep. Changing this rebuilds the LO plan live.
    gui_hint: 0,0,1,2
    label: Band(s) to jam
    label0: 2.4 GHz ISM (2392-2492 MHz)
    label1: 5.2 GHz (5190-5290 MHz)
    label2: Both bands
    label3: 5210 MHz only (single channel)
    num_opts: '4'
    option0: '"2g4"'
    option1: '"5g2"'
    option2: '"both"'
    option3: '"5210"'
    options: '[0, 1, 2, 3]'
    type: string
    value: '"both"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Initial LO frequency, set before the flowgraph starts. The embedded block retunes the radio from here via command messages, so this only needs to be a frequency the daughterboard can reach.
    value: '2442000000'
  states: {}
- name: device_addr
  id: variable
  parameters:
    comment: Empty takes the first device found; set a serial to pick one.
    value: '""'
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: chirp
  id: epy_block
  parameters:
    _source_code: |
      """Chirp sweep jammer with LO stepping across two 100 MHz bands.

      A linear chirp is generated across +/- samp_rate/2. The block also steps the
      USRP local oscillator by publishing 'freq' command messages on its message
      port; wire that port to a UHD Sink's command port and the LO tiles each band
      and alternates between them, covering far more spectrum than one sample_rate
      window. Sample rate, speed, dwell and band selection are all live: work()
      rebuilds the LO plan whenever the sample rate or band selection changes.
      """

      import math
      import time

      import numpy as np
      import pmt
      from gnuradio import gr

      # The two target bands as (low_hz, high_hz), matching the anti-jam link's
      # 2442 MHz and 5240 MHz allocations.
      # A zero-width entry is a single-frequency spot: one LO step, no hopping,
      # with the chirp still spreading across the sample_rate window.
      _BANDS = {
          "2g4": [(2_392_000_000, 2_492_000_000)],
          "5g2": [(5_190_000_000, 5_290_000_000)],
          "both": [(2_392_000_000, 2_492_000_000), (5_190_000_000, 5_290_000_000)],
          "5210": [(5_210_000_000, 5_210_000_000)],
      }


      class blk(gr.sync_block):
          def __init__(self, samp_rate=20e6, speed=1000.0, dwell=0.02, bands="both"):
              gr.sync_block.__init__(
                  self, name="Chirp Sweep Jammer", in_sig=None,
                  out_sig=[np.complex64],
              )
              self.samp_rate = float(samp_rate)
              self.speed = float(speed)
              self.dwell = float(dwell)
              self.bands = bands
              self.message_port_register_out(pmt.intern("command"))
              self._count = 0
              self._phase = 0.0
              self._index = 0
              self._next_step = 0.0
              self._built_for = None
              self._plan = [2_442_000_000.0]
              # The first real plan build and LO tune happen in start(), once the
              # command port is connected -- publishing here would go nowhere.

          # A live QT control writes straight to the attribute (GRC generates
          # e.g. self.chirp.samp_rate = ...), so no setters are needed: work()
          # reads speed and dwell fresh each call, and rebuilds the LO plan
          # whenever samp_rate or bands no longer match what it built for.
          def _rebuild_plan(self):
              centres = []
              for low, high in _BANDS.get(self.bands, _BANDS["both"]):
                  width = high - low
                  steps = max(1, math.ceil(width / self.samp_rate))
                  step_width = width / steps
                  for k in range(steps):
                      centres.append(low + step_width * (k + 0.5))
              self._plan = centres
              self._index = 0
              self._built_for = (self.samp_rate, self.bands)
              self._retune(self._plan[0])
              self._next_step = time.monotonic() + self.dwell

          def _retune(self, freq):
              # Print the current centre frequency on every LO step, so the
              # console shows the sweep walking across the bands.
              print("[sweep jammer] centre frequency -> %.3f MHz" % (freq / 1e6),
                    flush=True)
              self.message_port_pub(
                  pmt.intern("command"),
                  pmt.cons(pmt.intern("freq"), pmt.from_double(float(freq))),
              )

          def start(self):
              self._rebuild_plan()
              return True

          def work(self, input_items, output_items):
              if (self.samp_rate, self.bands) != self._built_for:
                  self._rebuild_plan()

              out = output_items[0]
              n = len(out)
              period = max(2.0, self.samp_rate / self.speed)
              idx = self._count + np.arange(n)
              inst = (idx % period) / period - 0.5
              phase = self._phase + 2.0 * np.pi * np.cumsum(inst)
              out[:] = np.exp(1j * phase).astype(np.complex64)
              self._phase = float(phase[-1] % (2.0 * np.pi))
              self._count += n

              if len(self._plan) > 1 and time.monotonic() >= self._next_step:
                  self._index = (self._index + 1) % len(self._plan)
                  self._retune(self._plan[self._index])
                  self._next_step = time.monotonic() + self.dwell
              return n
    bands: bands
    comment: Generates the chirp and, on its command port, the LO retune messages that tile both bands. Wire command -> USRP Sink command.
    dwell: dwell
    samp_rate: samp_rate
    speed: speed
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: antenna
    bw0: samp_rate
    center_freq0: center_freq
    comment: 'The command port receives freq retune messages from the chirp block, so its centre frequency follows the LO plan. HARDWARE WARNING: only radiate into a load or attenuator, in bands you are licensed to use.'
    dev_addr: device_addr
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: The baseband chirp being transmitted at the current LO step. Spans the full sample_rate window as the sweep runs.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: chirp
    name: '"Transmitted chirp (baseband)"'
    type: complex
    ymin: '-110'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: The diagonal streaks are the chirp sweeping across the window over time. The LO stepping is not visible here (this is baseband) but is happening on the radio.
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    int_min: '-110'
    name: '"Sweep over time"'
    type: complex
  states: {}

connections:
- [chirp, '0', usrp_sink, '0']
- [chirp, '0', spectrum, '0']
- [chirp, '0', waterfall, '0']
- [chirp, command, usrp_sink, command]

metadata:
  file_format: 1
