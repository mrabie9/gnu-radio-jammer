options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: GMSK command transmitter using a standard UHD USRP Sink
    generate_options: no_gui
    id: gmsk_command_tx_uhd
    output_language: python
    title: GMSK Command TX - UHD
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2440000000'
  states: {}
- name: device_addr
  id: variable
  parameters:
    value: '"serial=337D3DF"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '80'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: clock_source
  id: variable
  parameters:
    value: '"internal"'
  states: {}
- name: time_source
  id: variable
  parameters:
    value: '"internal"'
  states: {}
- name: tx
  id: gpsk_comms_gmsk_command_tx
  parameters:
    access_code: D391DA26
    bt: '0.35'
    cycle_period: '0.5'
    demo_cycle: 'False'
    hold_to_send: 'True'
    repeat_rate: '100'
    sample_rate: samp_rate
    samples_per_symbol: '4'
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: antenna
    bw0: bandwidth
    center_freq0: center_freq
    clock_source0: clock_source
    dev_addr: device_addr
    gain0: gain
    samp_rate: samp_rate
    time_source0: time_source
    type: fc32
  states: {}

connections:
- [tx, '0', usrp_sink, '0']

metadata:
  file_format: 1
