options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: Anti-jam command link loopback with a switchable jammer, no USRP hardware
    generate_options: no_gui
    id: aj_command_loopback
    output_language: python
    title: AJ Command Loopback
  states: {}

blocks:
- name: jam_amplitude
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: master_key
  id: variable
  parameters:
    value: generate_master_key()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '255'
  states: {}
- name: combiner
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: command_debug
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: command_strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.dict_add(pmt.make_dict(), pmt.intern("command"), pmt.intern("forward"))
    period: '1000'
  states: {}
- name: import_key
  id: import
  parameters:
    imports: from gpsk_comms.security import generate_master_key, load_master_key
  states: {}
- name: jammer
  id: analog_sig_source_x
  parameters:
    amp: jam_amplitude
    freq: samp_rate*0.13
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: rx
  id: gpsk_comms_aj_command_rx
  parameters:
    detection_threshold: '0.25'
    dwell_us: '100000'
    excision_enabled: 'True'
    grace_period: '0.0'
    hopping_enabled: 'False'
    interleave_depth: '17'
    master_key: master_key
    sample_rate: samp_rate
    spreading_factor: spreading_factor
    watchdog_timeout: '1.0'
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tx
  id: gpsk_comms_aj_command_tx
  parameters:
    dwell_us: '100000'
    hold_to_send: 'False'
    hopping_enabled: 'False'
    interleave_depth: '17'
    master_key: master_key
    repeat_rate: '20'
    sample_rate: samp_rate
    spreading_factor: spreading_factor
  states: {}

connections:
- [combiner, '0', throttle, '0']
- [command_strobe, strobe, tx, command]
- [jammer, '0', combiner, '1']
- [rx, command, command_debug, print]
- [throttle, '0', rx, '0']
- [tx, '0', combiner, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
