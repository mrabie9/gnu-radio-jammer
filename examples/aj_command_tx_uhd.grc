options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: Anti-jam command transmitter over a USRP. Pair with aj_command_rx_uhd.grc, launched at the same --level with the same key. Bring the link up from level 0 upwards; the first level that fails names the layer at fault.
    generate_options: qt_gui
    id: aj_command_tx_uhd
    output_language: python
    title: AJ Command TX - UHD
  states: {}

blocks:
- name: level
  id: parameter
  parameters:
    comment: |-
      Feature level 0-6. Must match the receiver's. A launch parameter and not a live control: each level changes which processing stages exist, and a running flowgraph cannot be rewired. Relaunch to change it.
      Level 6 is a special case here. Its LO retuning is computed but not applied to the radio: wiring a TimedRetuner to this flowgraph's USRP is application work that GRC cannot express, so on hardware level 6 behaves as level 5 with the schedule recorded. Use 5 unless you have wired the retuner yourself.
    label: Feature Level (0-6)
    short_id: l
    type: intx
    value: '0'
  states: {}
- name: import_gpsk
  id: import
  parameters:
    imports: from gpsk_comms.levels import LEVEL_NAMES, profile
  states: {}
- name: import_key
  id: import
  parameters:
    imports: from gpsk_comms.security import load_master_key
  states: {}
- name: master_key
  id: variable
  parameters:
    comment: |-
      Loaded from GPSK_COMMS_KEY_FILE or GPSK_COMMS_KEY, never written into this file. Both ends must hold the same key, so generate one once with "python3 -m gpsk_comms.security --output link.key" and copy it to the other machine over a trusted path.
      Asked for only from level 2, which is the first level that needs one. GRC evaluates this expression when it opens the file, so calling load_master_key() unconditionally would make the flowgraph refuse to open on a machine that has no key yet -- including for levels 0 and 1, whose whole purpose is to prove the radio before key distribution is working.
    value: load_master_key() if level >= 2 else None
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'The chip rate. Keep it low: the receiving end is Python and GNU Radio gives each block its own thread contending for one GIL, so a few hundred kilosamples per second is the budget on a typical host. On a real radio there is no backpressure to save you -- exceed it and the USRP drops samples.'
    value: '500000'
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    comment: Must match the receiver.
    value: '127'
  states: {}
- name: dwell_us
  id: variable
  parameters:
    comment: Hop dwell. Must match the receiver. Levels 5 and 6 refuse to build if a burst plus the receiver's search window will not fit inside one.
    value: '200000'
  states: {}
- name: repeat_rate
  id: variable
  parameters:
    comment: Bursts per second. Ignored from level 5 up, where exactly one burst is sent per hop dwell, aligned to the dwell boundary.
    value: '8'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Must match the receiver.
    value: '2440000000'
  states: {}
- name: device_addr
  id: variable
  parameters:
    comment: Set to your own radio, e.g. "serial=337D3DF". An empty string takes the first device found.
    value: '""'
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: clock_source
  id: variable
  parameters:
    value: '"internal"'
  states: {}
- name: time_source
  id: variable
  parameters:
    comment: Hopping derives the slot from the host wall clock, independently at each end -- there is no reverse channel to negotiate over. The two clocks must therefore agree to well within one dwell. Ordinary NTP is ample at a 200 ms dwell; a free-running clock that has never been set is not. If level 4 passes and level 5 does not, suspect time sync before suspecting the RF.
    value: '"internal"'
  states: {}
- name: level_summary
  id: variable
  parameters:
    value: '''level %d (%s) -- %s'' % (level, LEVEL_NAMES[level], '', ''.join(profile(level).enabled) or ''bare point-to-point link, no key'')'
  states: {}
- name: level_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,2
    label: Transmitting at
    type: string
    value: level_summary
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: Live. Start low and raise it only as far as the receiver needs.
    gui_hint: 3,0,1,2
    label: TX gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: keyboard
  id: gpsk_comms_keyboard_command_source
  parameters:
    comment: Click this panel to give it focus, then hold W/A/S/D to drive and press space to stop.
    gui_hint: 1,0,2,1
  states: {}
- name: tx
  id: gpsk_comms_aj_command_tx
  parameters:
    comment: 'hold_to_send is False so the link idles at "stop" and transmits continuously, which is what you want while bringing a link up: the receiver shows traffic straight away instead of nothing until a key is pressed. Set it True for a deployment, where releasing the controls should silence the transmitter and let the receiver''s watchdog command a stop.'
    dwell_us: dwell_us
    hold_to_send: 'False'
    interleave_depth: '17'
    level: level
    master_key: master_key
    repeat_rate: repeat_rate
    sample_rate: samp_rate
    spreading_factor: spreading_factor
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: antenna
    bw0: bandwidth
    center_freq0: center_freq
    clock_source0: clock_source
    dev_addr: device_addr
    gain0: tx_gain
    samp_rate: samp_rate
    time_source0: time_source
    type: fc32
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: 'What is going to the antenna: narrow at levels 0-2, spread across the band at 3 and up.'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,2,1
    label1: transmitted
    name: '"Transmitted spectrum"'
    type: complex
    ymin: '-110'
  states: {}
- name: tx_diagnostics
  id: blocks_message_debug
  parameters:
    comment: Quiet unless something is wrong. A clock_reanchor event means this host cannot keep up with samp_rate and the transmitter has fallen behind the wall clock its hop schedule comes from -- lower samp_rate if it repeats, because at level 5 and above it will desynchronise the link.
  states: {}

connections:
- [keyboard, command, tx, command]
- [tx, '0', usrp_sink, '0']
- [tx, '0', spectrum, '0']
- [tx, diagnostics, tx_diagnostics, print]

metadata:
  file_format: 1
