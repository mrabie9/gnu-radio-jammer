options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: 'Standalone barrage jammer: wideband Gaussian noise radiated across an adjustable bandwidth centred on an adjustable frequency. The noise fills the whole sampled window, so the occupied bandwidth equals the sample rate, which is driven directly by the Bandwidth slider. WARNING: this transmits -- only radiate in bands you are licensed for, into a load or attenuator.'
    generate_options: qt_gui
    id: barrage_jammer
    output_language: python
    title: Barrage Jammer
  states: {}

blocks:
- name: device_addr
  id: variable
  parameters:
    comment: Empty takes the first device found; set a serial to pick one.
    value: '""'
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: The transmit LO. Check this is inside an allocation you are permitted to radiate in before turning the gain up. Live.
    gui_hint: 0,0,1,1
    label: Centre frequency (Hz)
    orient: Qt.Horizontal
    start: '2300000000'
    step: '1000000'
    stop: '5900000000'
    value: '2442000000'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    comment: 'Width of the noise, in Hz. This is the USRP sample rate: the noise fills the whole sampled window, so the occupied bandwidth is exactly this value. Live, though a real radio may glitch briefly as it changes rate. Keep it within what the device and its link can sustain.'
    gui_hint: 0,1,1,1
    label: Bandwidth (Hz)
    orient: Qt.Horizontal
    start: '200000'
    step: '100000'
    stop: '56000000'
    value: '20000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: USRP transmit gain in dB. Live. Start low.
    gui_hint: 1,0,1,1
    label: TX gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    comment: Digital noise level before the radio. Gaussian noise has occasional large peaks, so keep this well below 1 to avoid clipping the DAC; use TX gain for output power. Live.
    gui_hint: 1,1,1,1
    label: Noise amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: amplitude
    comment: Complex white Gaussian noise -- the barrage waveform. Flat across the whole sampled window.
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: antenna
    bw0: bandwidth
    center_freq0: center_freq
    comment: 'HARDWARE WARNING: only radiate into a load or attenuator, in bands you are licensed to use. samp_rate is driven by the Bandwidth slider.'
    dev_addr: device_addr
    gain0: gain
    samp_rate: bandwidth
    type: fc32
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: bandwidth
    comment: The radiated noise. Centred on center_freq so the axis reads real RF frequency; a flat plateau of width bandwidth is what a barrage looks like.
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: noise
    name: '"Barrage noise"'
    type: complex
    ymin: '-110'
  states: {}

connections:
- [noise, '0', usrp_sink, '0']
- [noise, '0', spectrum, '0']

metadata:
  file_format: 1
