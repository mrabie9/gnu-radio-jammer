options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: Anti-jam command link loopback with a switchable jammer, no USRP hardware
    generate_options: no_gui
    id: aj_command_loopback
    output_language: python
    title: AJ Command Loopback
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 2.442e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '90'
  states: {}
- name: jam_amplitude
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: master_key
  id: variable
  parameters:
    value: generate_master_key()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '255'
  states: {}
- name: command_debug
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: import_key
  id: import
  parameters:
    imports: from gpsk_comms.security import generate_master_key, load_master_key
  states: {}
- name: rx
  id: gpsk_comms_aj_command_rx
  parameters:
    detection_threshold: '0.25'
    dwell_us: '100000'
    excision_enabled: 'True'
    grace_period: '0.0'
    hopping_enabled: 'False'
    interleave_depth: '17'
    master_key: master_key
    sample_rate: samp_rate
    spreading_factor: spreading_factor
    watchdog_timeout: '1.0'
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    bw0: samp_rate
    center_freq0: centre_freq
    clock_source0: clock_source
    dev_addr: device_addr
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    time_source0: time_source
    type: fc32
  states: {}

connections:
- [rx, command, command_debug, print]
- [usrp_source, '0', rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
