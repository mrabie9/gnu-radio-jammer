options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: 'Standalone replay attack. A previously captured complex baseband IQ recording (cf32 / gr_complex file) is looped out of a USRP. Centre frequency, sample rate and the target band (2392-2492 MHz or 5190-5290 MHz) are live sliders. The band chooser reframes the centre-frequency slider to the selected 100 MHz allocation; pick the band before you press Run (see the note on the band block). WARNING: this transmits. Only radiate in bands you are licensed for, into a load or attenuator. Both default bands overlap licensed services -- replaying a captured signal over the air may be illegal.'
    generate_options: qt_gui
    id: replay_attack
    output_language: python
    title: Replay Attack - captured IQ playback
  states: {}

blocks:
- name: band
  id: variable_qtgui_chooser
  parameters:
    comment: 'Target allocation. Each option is a (low_hz, high_hz) tuple; the centre-frequency slider spans whichever band is selected here. Switching band while running snaps the radio to that band''s centre frequency. NOTE: the slider''s min/max endpoints are fixed when the flowgraph starts, so to slide freely across the other band, restart after changing this.'
    gui_hint: 0,0,1,2
    label: Target band
    num_opts: '2'
    type: raw
    value: (2392e6, 2492e6)
    option0: (2392e6, 2492e6)
    label0: 2.4 GHz (2392-2492 MHz)
    option1: (5190e6, 5290e6)
    label1: 5.2 GHz (5190-5290 MHz)
    options: '[]'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: USRP transmit centre frequency, in Hz. The slider spans the band chosen above. Live within the band.
    gui_hint: 1,0,1,2
    label: Centre frequency (Hz)
    start: band[0]
    step: '1000000'
    stop: band[1]
    value: (band[0] + band[1]) / 2
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    comment: USRP sample rate, in Hz. For time-correct playback set this to the rate the file was recorded at. Live.
    gui_hint: 2,0,1,1
    label: Sample rate (Hz)
    start: '1000000'
    step: '1000000'
    stop: '56000000'
    value: '20000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: USRP transmit gain in dB. Live. Start low.
    gui_hint: 2,1,1,1
    label: TX gain (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    comment: Digital scale applied to the replayed samples before the radio. 1.0 is the file as recorded. Live.
    gui_hint: 3,0,1,2
    label: Replay amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os, tempfile
  states: {}
- name: capture_file
  id: variable
  parameters:
    comment: Path to the captured complex baseband recording (interleaved 32-bit float I/Q, i.e. gr_complex / cf32), in the system temp dir. Produced by replay_capture.grc; must exist before you run this. Capture and replay at the same sample rate.
    value: os.path.join(tempfile.gettempdir(), "capture.cf32")
  states: {}
- name: device_addr
  id: variable
  parameters:
    comment: Empty takes the first device found; set a serial to pick one.
    value: '""'
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    add_begin_tag: pmt.PMT_NIL
    comment: The captured recording, looped forever so the replay runs continuously.
    file: capture_file
    repeat: 'True'
    type: complex
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: Applies the replay amplitude slider.
    const: amplitude
    type: complex
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: device_addr
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: Baseband spectrum of the recording being replayed.
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,0,1,1
    label1: replay
    name: '"Replayed signal (baseband)"'
    type: complex
    ymin: '-110'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Replayed signal over time.
    fc: center_freq
    fftsize: '1024'
    gui_hint: 4,1,1,1
    int_min: '-110'
    name: '"Replay over time"'
    type: complex
  states: {}

connections:
- [file_source, '0', scale, '0']
- [scale, '0', usrp_sink, '0']
- [scale, '0', spectrum, '0']
- [scale, '0', waterfall, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
