options:
  parameters:
    author: gpsk_comms
    category: Custom
    description: Anti-jam command link loopback with a switchable jammer, no USRP hardware
    generate_options: no_gui
    id: aj_command_loopback
    output_language: python
    title: AJ Command Loopback
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 2.442e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '90'
  states: {}
- name: jam_amplitude
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: master_key
  id: variable
  parameters:
    value: generate_master_key()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '255'
  states: {}
- name: import_key
  id: import
  parameters:
    imports: from gpsk_comms.security import generate_master_key, load_master_key
  states: {}
- name: tx
  id: gpsk_comms_aj_command_tx
  parameters:
    dwell_us: '100000'
    hold_to_send: 'False'
    hopping_enabled: 'False'
    interleave_depth: '17'
    master_key: master_key
    repeat_rate: '20'
    sample_rate: samp_rate
    spreading_factor: spreading_factor
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: centre_freq
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [tx, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
